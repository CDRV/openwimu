# IAR project WIMU.ewp, settings and files
configuration CC2540F128-WIMU (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F128.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; xHAL_ISR=TRUE; xHAL_UART_ISR=TRUE; xHAL_UART_ISR=2; xZAPP_P2=TRUE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_UART_DMA=2
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt; ..\..\Profiles\HIDDev; ..\..\Profiles\ScanParam; ..\..\Profiles\SensorProfile; ..\..\util\WIMU; ..\..\Profiles\Actimetry; ..\..\Profiles\Gps; ..\..\Profiles\TimeService
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540f128b.xcl
  group APP
    ../Source/: OSAL_WIMU.c wimu.c wimu.h WIMU_Main.c
    ../../util/WIMU/: wimu_util.c wimu_util.h
  group HAL/Common
    ../../../../COMPONENTS/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_led.c hal_sleep.c hal_timer.c
    ../../../../COMPONENTS/hal/target/CC2540EB/: hal_startup.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../COMPONENTS/osal/common/: OSAL.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_Timers.c
    ../../../../Components/osal/common/: osal_bufmgr.c osal_cbtimer.c OSAL_PwrMgr.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/ACTIMETRY/: actimetryservice.c
    ../../Profiles/Actimetry/: actimetryservice.h
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../COMPONENTS/ble/host/: gatt_uuid.c
    ../../Profiles/GPS/: gpsservice.c gpsservice.h
    ../../Profiles/HIDDev/: hid_uuid.h hiddev.c hiddev.h
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/Keys/: simplekeys.c simplekeys.h
    ../../Profiles/SENSORPROFILE/: st_util.c
    ../../Profiles/SensorProfile/: st_util.h
    ../../Profiles/TimeService/: timeservice.c timeservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
